Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 88d6a825-12d6-4a2a-865b-f4d1830ecdf7, NumberOfSaves: 1]
File name: 0001
Time: 2026-08-24T08:16:37+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12698890_D_TQ1000WP_LW:12Q10001_D_12698890_TQ1000WP_LW, (2)
In: Default
Type - Material: z_Miele_Design_Zinc_Steel, z_Miele_Connection_Water_OUT, z_Miele_Connection_Water_IN, z_Miele_Connection_Electric, <Unnamed>, z_Miele_Design_Powder Coat_Lotus White
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 596 mm; Height: 850 mm; Depth: 644 mm
Classification: E1010610 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 12Q10001_D_12698890_TQ1000WP_LW; sets with these values: 2

# IfcDistributionPort, Port_360235_1
Description: Flow; FlowDirection: SOURCEANDSINK
